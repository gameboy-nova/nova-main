# Keil uVision project gameboy.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gameboy +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.s chars.s main_assets.s main_message.s logo.s
    ./PONG/: Pong.s pong_assets.s
    ./PAINTER/: painter.s selecter_data.s
    ./SNAKE/: double_snake.s double_snake_assets.s double_snake_messages.s Snake.s snake_assets.s SnakeMessages.s
    ./STAR_BLAST/: shooter_assets.s shooter_game.s shooter_messages.s
    ./Fruit/: APPLE.s Basket.s MELON.s ORANGE.s PEAR.s Fruit.s
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
